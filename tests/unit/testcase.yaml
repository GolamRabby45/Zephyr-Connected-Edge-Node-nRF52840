## tests/unit/testcase.yaml
```yaml
tests:
  edge.telemetry.pipeline_math:
    platform_allow:
      - native_sim
    tags:
      - unit
      - pipeline
    harness: ztest
```
